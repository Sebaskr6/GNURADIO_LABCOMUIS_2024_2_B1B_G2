options:
  parameters:
    author: labcomu
    generate_options: qt_gui
    id: AM_MODULATOR
    output_language: python
    title: AM_MODULATOR
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud de la portadora '
    start: '0'
    step: '1E-3'
    stop: '1'
    value: '125E-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud del mensaje '
    start: '0'
    step: '100E-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1E3
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita Portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625E6
  states: {}
- name: a_0
  id: a
  parameters:
    Ac: Ac
    ka: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: y
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [a_0, '0', qtgui_freq_sink_x_0, '0']
- [a_0, '0', qtgui_time_sink_x_0, '0']
- [a_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', a_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
