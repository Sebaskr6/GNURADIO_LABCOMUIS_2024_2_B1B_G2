options:
  parameters:
    author: labcomu
    generate_options: qt_gui
    id: randommodulada
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud de la portadora '
    start: '0'
    step: '1E-3'
    stop: '1'
    value: '125E-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud del mensaje '
    start: '0'
    step: '100E-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: '# muestras por simbolo'
    rangeType: int
    start: '1'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1E3
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita Portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100E-3'
    stop: '4'
    value: '1'
  states: {}
- name: n
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1.5625E6
  states: {}
- name: a_0
  id: a
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-(math.pow(2,n)-1)/2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(math.pow(2,n))
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: B
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: y
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [a_0, '0', qtgui_freq_sink_x_0, '0']
- [a_0, '0', qtgui_time_sink_x_0, '0']
- [a_0, '0', uhd_usrp_sink_0, '0']
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', a_0, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
